# Keil uVision project DFDL33_SH8619_BOOT.uvprojx, settings and files
target DFDL33_SH8619_BOOT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F403ARGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DFDL33_SH8619_BOOT +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403ARGT7, USE_STDPERIPH_DRIVER, AT_START_F403A_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\User\UserApp;..\..\User\UserDrv
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c wk_system.c wk_debug.c wk_spi.c wk_wdt.c wk_gpio.c wk_usart.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_gpio.c at32f403a_407_usart.c at32f403a_407_pwc.c at32f403a_407_spi.c at32f403a_407_flash.c at32f403a_407_wdt.c at32f403a_407_misc.c at32f403a_407_debug.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group UserApp
    ../../User/UserApp/: data_analysis.c data_analysis.h int_flash_mgmt.c int_flash_mgmt.h version.c version.h
  group UserDrv
    ../../User/UserDrv/: crc8.c crc8.h crc16.c crc16.h crc32.c crc32.h drv_zd25q64.c drv_zd25q64.h jumpAPP.c jumpAPP.h my_drv.c my_drv.h my_printf.c my_printf.h my_vsnprintf.c my_vsnprintf.h spi_flash.c spi_flash.h
